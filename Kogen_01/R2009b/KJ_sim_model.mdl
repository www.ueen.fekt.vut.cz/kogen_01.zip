simulink model "KJ_sim_model"  (Simulink 7.4)
settings: Solver=ode45  StartTime=0.0  StopTime=86400.0  MaxStep=10  RelTol=1e-3
values from neighbouring files (symbols this model uses):
  c = 4180    [KJ_GUI.m]
  hod = 3600    [KJ_GUI.m]
  k_an = 0.5    [KJ_GUI.m]
  k_kj = 0.5    [KJ_GUI.m]
  k_sv = q_sv_pozad/q_rand    [KJ_GUI.m]
  k_tuv = 100    [KJ_GUI.m]
  k_ut = P_ut*k_ztrat*1000/deltaT    [KJ_GUI.m]
  KJ_1A = 5*hod    (= 18000)    [KJ_GUI.m]
  KJ_1B = 9*hod    (= 32400)    [KJ_GUI.m]
  KJ_2A = 16*hod    (= 57600)    [KJ_GUI.m]
  KJ_2B = 22*hod    (= 79200)    [KJ_GUI.m]
  ni1 = str2double(x)/100    [KJ_GUI.m]
  ni2 = str2double(x)/100    [KJ_GUI.m]
  P = 1/1000000    (= 1e-06)    [KJ_GUI.m]
  P_el = str2double(x)*1000    [KJ_GUI.m]
  Pel = 1/(3600*1000)    (= 2.77777777778e-07)    [KJ_GUI.m]
  Pn = str2double(x)*1000    [KJ_GUI.m]
  Pn2 = str2double(x)*1000    [KJ_GUI.m]
  q_tuv_c = 0.1    [KJ_GUI.m]
  q_ut = 0.2    [KJ_GUI.m]
  qn = 0.2    [KJ_GUI.m]
  ro = 1000    [KJ_GUI.m]
  S_ank = (2*pi*r*v/p)+(pi*r*r)    [KJ_GUI.m]
  S_anv = (2*pi*r*v/p)    [KJ_GUI.m]
  S_kj = 1    [KJ_GUI.m]
  S_tuv = 6.7/p    (= 1.11666666667)    [KJ_GUI.m]
  T0_an = 60    [KJ_GUI.m]
  T0_kj = 50    [KJ_GUI.m]
  T0_tuv = 50    [KJ_GUI.m]
  To = 20    [KJ_GUI.m]
  Tp = 22    [KJ_GUI.m]
  Tsv = 15    [KJ_GUI.m]    (also in KJgui_letni_provoz.m = evalin('base', 'Tsv'); KJgui_zimni_provoz.m = evalin('base', 'Tsv'))
  Ttuv_poz = str2double(x)    [KJ_GUI.m]
  Tut_poz = str2double(x)    [KJ_GUI.m]
  TUV_1a = str2double(x)    [KJ_GUI.m]
  TUV_1b = str2double(x)    [KJ_GUI.m]
  TUV_2a = str2double(x)    [KJ_GUI.m]
  TUV_2b = str2double(x)    [KJ_GUI.m]
  TUV_3a = str2double(x)    [KJ_GUI.m]
  TUV_3b = str2double(x)    [KJ_GUI.m]
  TUVon = str2double(TUVon_s)    [KJ_GUI.m]
  TUVsmes = str2double(TUVsmes_s)    [KJ_GUI.m]
  UT_1a = str2double(x)    [KJ_GUI.m]
  UT_1b = str2double(x)    [KJ_GUI.m]
  UT_2a = str2double(x)    [KJ_GUI.m]
  UT_2b = str2double(x)    [KJ_GUI.m]
  UT_3a = str2double(x)    [KJ_GUI.m]
  UT_3b = str2double(x)    [KJ_GUI.m]
  UTon = str2double(UTon_s)    [KJ_GUI.m]
  UTsmes = str2double(UTsmes_s)    [KJ_GUI.m]
  V = 0.708    [KJ_GUI.m]
  V_an = Vc/p    (= 0.125)    [KJ_GUI.m]
  V_kj = 0.005    [KJ_GUI.m]
  V_tuv = Vp/p    (= 0.005)    [KJ_GUI.m]
libraries: simulink x6
(part 2 of 2)

== system KJ_sim_model/Regulace TUV/Subsystem1 ==
  Constant2 : Constant
  Constant3 : Constant  Value=0
  On : Outport
  Off : Outport  Port=2
  wires:
  Constant2/1 -> On/1
  Constant3/1 -> Off/1

== system KJ_sim_model/Regulace TUV/q1 ==
  I : Inport
  Product : Product
  "q_tuv " : Outport
  wires:
  I/1 -> Product/1
  Product/1 -> "q_tuv "/1
  [q_tuv] -> Product/2

== system KJ_sim_model/Regulace TUV/q2 ==
  I : Inport
  Product : Product
  "q_tuv " : Outport
  wires:
  I/1 -> Product/1
  Product/1 -> "q_tuv "/1
  [q_tuv] -> Product/2

== system KJ_sim_model/Regulace TUV/q4 ==
  I : Inport
  Product : Product
  " q_tuv " : Outport
  wires:
  I/1 -> Product/1
  Product/1 -> " q_tuv "/1
  [q_tuv] -> Product/2

== system KJ_sim_model/Regulace UT/Logika1 ==
  In1 : Inport
  Ground : Ground
  Switch : Switch  Criteria=u2 > Threshold
  Out1 : Outport
  wires:
  In1/1 -> Switch/1
  Switch/1 -> Out1/1
  [UT] -> Switch/2
  Ground/1 -> Switch/3

== system KJ_sim_model/Regulace UT/Logika2 ==
  In1 : Inport
  Ground : Ground
  Switch : Switch  Criteria=u2 > Threshold
  Out1 : Outport
  wires:
  Ground/1 -> Switch/3
  [UT] -> Switch/2
  Switch/1 -> Out1/1
  In1/1 -> Switch/1

== system KJ_sim_model/Regulace UT/Logika3 ==
  In1 : Inport
  Constant : Constant
  Switch : Switch  Criteria=u2 > Threshold
  Out1 : Outport
  wires:
  In1/1 -> Switch/1
  Switch/1 -> Out1/1
  [UT] -> Switch/2
  Constant/1 -> Switch/3

== system KJ_sim_model/Regulace UT/Logika4 ==
  In1 : Inport
  Ground : Ground
  Switch : Switch  Criteria=u2 > Threshold
  Out1 : Outport
  wires:
  In1/1 -> Switch/1
  Switch/1 -> Out1/1
  [UT] -> Switch/2
  Ground/1 -> Switch/3

== system KJ_sim_model/Regulace UT/Subsystem1 ==
  Constant2 : Constant
  Constant3 : Constant  Value=0
  On : Outport
  Off : Outport  Port=2
  wires:
  Constant2/1 -> On/1
  Constant3/1 -> Off/1

== system KJ_sim_model/Regulace UT/q1 ==
  I : Inport
  Product : Product
  "q_ut " : Outport
  wires:
  I/1 -> Product/1
  Product/1 -> "q_ut "/1
  [q_ut] -> Product/2

== system KJ_sim_model/Regulace UT/q2 ==
  I : Inport
  Product : Product
  "q_ut " : Outport
  wires:
  I/1 -> Product/1
  Product/1 -> "q_ut "/1
  [q_ut] -> Product/2

== system KJ_sim_model/Ridici jednotka/casovy plan KJ ==
  KJ_1A : Step  Time=KJ_1A  SampleTime=0
  KJ_1B : Step  Time=KJ_1B  After=-1  SampleTime=0
  KJ_2A : Step  Time=KJ_2A  SampleTime=0
  KJ_2B : Step  Time=KJ_2B  After=-1  SampleTime=0
  Sum : Sum  Inputs=|++
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum
  casovy plan KJ : Scope
  KJ : Outport
  wires:
  Sum1/1 -> Sum2/2
  Sum/1 -> Sum2/1
  Sum2/1 -> casovy plan KJ/1, KJ/1
  KJ_2B/1 -> Sum1/2
  KJ_2A/1 -> Sum1/1
  KJ_1B/1 -> Sum/2
  KJ_1A/1 -> Sum/1

== system KJ_sim_model/Ridici jednotka/casovy plan TUV ==
  Sum : Sum  Inputs=|++
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=+++
  Sum3 : Sum  Inputs=|++
  TUV_1a : Step  Time=TUV_1a*hod  SampleTime=0
  TUV_1b : Step  Time=TUV_1b*hod  After=-1  SampleTime=0
  TUV_2a : Step  Time=TUV_2a*hod  SampleTime=0
  TUV_2b : Step  Time=TUV_2b*hod  After=-1  SampleTime=0
  TUV_3a : Step  Time=TUV_3a*hod  SampleTime=0
  TUV_3b : Step  Time=TUV_3b*hod  After=-1  SampleTime=0
  To Workspace1 : ToWorkspace  VariableName=CP_TUV  SampleTime=-1
  casovy plan TUV : Scope
  TUV : Outport
  wires:
  TUV_1a/1 -> Sum/1
  TUV_1b/1 -> Sum/2
  TUV_2a/1 -> Sum1/1
  TUV_2b/1 -> Sum1/2
  Sum2/1 -> TUV/1, casovy plan TUV/1, To Workspace1/1
  Sum/1 -> Sum2/1
  Sum1/1 -> Sum2/2
  TUV_3a/1 -> Sum3/1
  TUV_3b/1 -> Sum3/2
  Sum3/1 -> Sum2/3

== system KJ_sim_model/Ridici jednotka/casovy plan UT ==
  17hodin : Step  Time=UT_2a*hod  SampleTime=0
  17hodin1 : Step  Time=UT_3a*hod  SampleTime=0
  22hodin : Step  Time=UT_2b*hod  After=-1  SampleTime=0
  22hodin1 : Step  Time=UT_3b*hod  After=-1  SampleTime=0
  6hodin : Step  Time=UT_1a*hod  SampleTime=0
  9hodin : Step  Time=UT_1b*hod  After=-1  SampleTime=0
  Sum : Sum  Inputs=|++
  Sum1 : Sum  Inputs=|++
  Sum2 : Sum  Inputs=+++
  Sum3 : Sum  Inputs=|++
  To Workspace1 : ToWorkspace  VariableName=CP_UT  SampleTime=-1
  casovy plan UT : Scope
  UT : Outport
  wires:
  6hodin/1 -> Sum/1
  9hodin/1 -> Sum/2
  17hodin/1 -> Sum1/1
  22hodin/1 -> Sum1/2
  Sum2/1 -> To Workspace1/1, UT/1, casovy plan UT/1
  Sum/1 -> Sum2/1
  Sum1/1 -> Sum2/2
  17hodin1/1 -> Sum3/1
  22hodin1/1 -> Sum3/2
  Sum3/1 -> Sum2/3

== system KJ_sim_model/q4/Logika ==
  In1 : Inport
  Ground : Ground
  Switch : Switch  Criteria=u2 > Threshold
  Out1 : Outport
  wires:
  In1/1 -> Switch/1
  Switch/1 -> Out1/1
  [UT] -> Switch/2
  Ground/1 -> Switch/3

== system KJ_sim_model/Akumulacni nadrz/Element 1/Subsystem ==
  In1 : Inport
  Product1 : Product
  " q_ut_a" : Outport
  wires:
  Product1/1 -> " q_ut_a"/1
  In1/1 -> Product1/1
  [q_ut_a] -> Product1/2

== system KJ_sim_model/Akumulacni nadrz/Element 2/Subsystem ==
  In1 : Inport
  Product1 : Product
  " q_ut_a" : Outport
  wires:
  Product1/1 -> " q_ut_a"/1
  In1/1 -> Product1/1
  [q_ut_a] -> Product1/2

== system KJ_sim_model/Akumulacni nadrz/Element 3/Subsystem ==
  In1 : Inport
  Product1 : Product
  " q_ut_a" : Outport
  wires:
  Product1/1 -> " q_ut_a"/1
  In1/1 -> Product1/1
  [q_ut_a] -> Product1/2

== system KJ_sim_model/Akumulacni nadrz/Element 4/Subsystem ==
  In1 : Inport
  Product1 : Product
  " q_ut_a" : Outport
  wires:
  Product1/1 -> " q_ut_a"/1
  In1/1 -> Product1/1
  [q_ut_a] -> Product1/2

== system KJ_sim_model/Akumulacni nadrz/Element 5/Subsystem ==
  In1 : Inport
  Product1 : Product
  " q_ut_a" : Outport
  wires:
  Product1/1 -> " q_ut_a"/1
  In1/1 -> Product1/1
  [q_ut_a] -> Product1/2

== system KJ_sim_model/Akumulacni nadrz/Element 6/Subsystem ==
  In1 : Inport
  Product1 : Product
  " q_ut_a" : Outport
  wires:
  Product1/1 -> " q_ut_a"/1
  In1/1 -> Product1/1
  [q_ut_a] -> Product1/2
